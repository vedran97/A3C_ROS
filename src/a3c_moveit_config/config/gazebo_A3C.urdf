Commit message: Finished Rviz Pick And Place implementation

File: src/a3c_moveit_config/config/gazebo_A3C.urdf (robot description, URDF)
Before this commit: robot A3C, 20 links, 19 joints
Links:
- added link world
Joints:
- added joint fixture: type fixed, parent world, child base
